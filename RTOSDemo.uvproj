# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo_ARM (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOSDemo
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS
  c include: .;..\..\Source\portable\RVDS\ARM7_LPC21xx;..\Common\include;..\..\Source\include
  asm include: ..\..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Other
    ./: Startup.s main.c
    ./ParTest/: ParTest.c
    ./serial/: serialISR.s
    ./Starter_Files_V1/source/: GPIO.c GPIO_cfg.c serial.c
  group FreeRTOS
    ./Source/: list.c queue.c tasks.c
    ./Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    ./Source/portable/MemMang/: heap_2.c
target RTOSDemo_THUMB (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: as above
  output: RTOSDemo +hex
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: .;.\Source\include;.\Common\include;.\Source\portable\RVDS\ARM7_LPC21xx;.\Starter_Files_V1\lib;.\Starter_Files_V1\header
  asm include: .\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
